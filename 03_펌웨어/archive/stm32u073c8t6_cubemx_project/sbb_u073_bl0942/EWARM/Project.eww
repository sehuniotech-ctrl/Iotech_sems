<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\sbb_u073_bl0942.ewp</path>
  </project>
  <batchBuild />
</workspace>
