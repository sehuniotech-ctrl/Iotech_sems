# IAR project sbb_u073_bl0942.ewp, settings and files
configuration sbb_u073_bl0942 (ARM, debug)
  General.OGChipSelectEditMenu: STM32U073C8 ST STM32U073C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32U073xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32U0xx_HAL_Driver/Inc; ../Drivers/STM32U0xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32U0xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: sbb_u073_bl0942.hex
  ILINK.IlinkOutputFile: sbb_u073_bl0942.out
  ILINK.IlinkIcfFile: stm32u073x8_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32u073xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32u0xx_it.c stm32u0xx_hal_msp.c
  group Drivers/STM32U0xx_HAL_Driver
    ../Drivers/STM32U0xx_HAL_Driver/Src/: stm32u0xx_hal_cortex.c stm32u0xx_hal_rcc.c stm32u0xx_hal_rcc_ex.c stm32u0xx_hal_flash.c stm32u0xx_hal_flash_ex.c stm32u0xx_hal_gpio.c stm32u0xx_hal_dma.c stm32u0xx_hal_dma_ex.c stm32u0xx_hal_pwr.c stm32u0xx_hal_pwr_ex.c stm32u0xx_hal.c stm32u0xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32u0xx.c
